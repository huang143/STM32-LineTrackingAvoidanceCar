# Keil uVision project LineTrackingCar.uvprojx, settings and files
target LineTrackingCar (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: LineTrackingCar +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\Hardware\ELE_CCD; ..\Hardware\ENCODER; ..\Hardware\KEY; ..\Hardware\LED; ..\Hardware\OLED; ..\Hardware\PSTWO; ..\Hardware\STMFLASH; ..\Hardware\USART3; ..\BALANCE\CONTROL; ..\BALANCE\DATASCOP_DP; ..\BALANCE\MPU6050; ..\BALANCE\SHOW; ..\SYSTEM\delay; ..\SYSTEM\sys; ..\Hardware\IIC; ..\Hardware\TRACK; ..\Hardware\ULTRASONIC; ..\Hardware\CAMERA
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Hardware
    ../Hardware/ELE_CCD/: ele_ccd.c
    ../Hardware/ENCODER/: encoder.c
    ../Hardware/KEY/: key.c
    ../Hardware/LED/: led.c
    ../Hardware/OLED/: oled.c
    ../Hardware/PSTWO/: pstwo.c
    ../Hardware/STMFLASH/: stmflash.c
    ../Hardware/USART3/: usart3.c
    ../Hardware/IIC/: IOI2C.c
    ../Hardware/TRACK/: track.c
    ../Hardware/ULTRASONIC/: ultrasonic.c
    ../Hardware/CAMERA/: camera.c
  group System
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group Control
    ../BALANCE/CONTROL/: control.c
    ../BALANCE/DATASCOP_DP/: DataScop_DP.c
    ../BALANCE/MPU6050/: filter.c inv_mpu.c inv_mpu_dmp_motion_driver.c MPU6050.c
    ../BALANCE/SHOW/: show.c
software components: CMSIS:CORE 4.3.0
